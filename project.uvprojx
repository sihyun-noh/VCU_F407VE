# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5_06)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin --output ./Objects/project.bin ./Objects/project.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\hardware;.\library;.\start;.\user;.\system;.\rtthread\3.0.3\include;.\rtthread\3.0.3\include\libc;.\rtthread\3.0.3\components\finsh;.\Internet
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group start
    ./start/: startup_stm32f40_41xxx.s core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group library
    ./library/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group hardware
    ./hardware/: AD.c AD.h LED.c LED.h CAN.c CAN.h MPU6050.c MPU6050.h MPU6050_Reg.h MyIIC.c MyIIC.h bsp_i2c_ee.c bsp_i2c_ee.h modbus.c modbus.h 485_4.c 485_4.h 485_3.c 485_3.h 232_2.c 232_2.h 232_1_modbus.c 232_1_modbus.h can2.c can2.h IO_10_Out.c IO_10_Out.h TH.c TH.h bsp_sd.c bsp_sd.h MySPI.c MySPI.h SBUS_UART.c SBUS_UART.h EC800_USART.c EC800_USART.h IO_10_IN.c IO_10_IN.h CAN_AGMO.c CAN_AGMO.h SBUS_AGMO.c SBUS_AGMO.h
  group user
    ./user/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h main.h board.h board.c rtconfig.h vcu_gateway.c vcu_gateway.h
  group system
    ./system/: dac.c dac.h delay.c delay.h PWM.c PWM.h
    ./hardware/: PWM_OUT.c PWM_OUT.h PWM_IN.c PWM_IN.h
  group Internet
    ./Internet/: dhcp.c dhcp.h dns.c dns.h socket.c socket.h spi.c spi.h w5500.c w5500.h wizchip_conf.c wizchip_conf.h
  group rtt_source
    ./rtthread/3.0.3/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rtt_ports
    ./rtthread/3.0.3/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
